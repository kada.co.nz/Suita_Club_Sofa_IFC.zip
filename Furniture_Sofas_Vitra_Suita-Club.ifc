Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-09-19T15:56:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 19 15:56:12 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{46E8F35E-CD7B-4DD5-AC2A-74EAACD4D01F}\ifc * Database version: 5507 * Database creation date: Thu Sep 19 15:56:11 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 19 15:56:12 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 19 15:56:12 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Suita Club Sofa, Furniture_Sofas_Vitra_Suita-Club:Suita Club Sofa:394082
In: Level 1
Type - Material: Aluminium polished 03, Leather standard dimgrey 21
Type - Dimensions(Type) - NominalDepth: 731.902 mm; NominalHeight: 697.89 mm; NominalLength: 1704.97 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Sofas_Vitra_Suita-Club; ConvergoRefNr: 0089-1909-0020-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The Suita Club Sofa was developed for use in offices, waiting areas and lobbies. The construction and workmanship are designed to withstand the demanding conditions of such public areas. The upholstery of the backrest ensures a high degree of comfort without the need for additional cushions.; Revision: n/a; Uniclass2: Pr_40_50_12_81; Uniclass2015Description: Sofas; Uniclass2015Reference: Pr_40_50_12_81; Version: 1; VersionDate: 18/09/19
Type - Identity Data(Type) - Collection: Suita Club; Cost: 0; Description: The Suita Club Sofa was developed for use in offices, waiting areas and lobbies. The construction and workmanship are designed to withstand the demanding conditions of such public areas. The upholstery of the backrest ensures a high degree of comfort without the need for additional cushions.; Designer: Antonio Citterio; Manufacturer: Vitra; Model: Suita Club Sofa; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; ProductDatasheet: https://www.vitra.com/en-us/_storage/asset/882737/storage/master/download/Factsheet%20Suita%20Club%20Sofa-EN.pdf; Type Name: Suita Club Sofa; URL: https://www.vitra.com/en-us/living/product/details/suita-club-sofa
Type - Materials and Finishes(Type) - SofaMainMaterial: Leather standard dimgrey 21; SofaSecondaryMaterial: Aluminium polished 03
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Sofas; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Sofas_Vitra_Suita-Club; Features: Legs: die-cast aluminium, polished or powder-coated. Body: webbed metal frame with moulded polyurethane foam.; Finish: n/a; Grade: n/a; Material: Aluminium, polyurethane & leather; ModelNumber: n/a; ModelReference: 21033800; Name: Vitra_Suita-Club; ReplacementCost: n/a; Shape: Sculptured; Size: 1705x725x700 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 21033800; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 2.94854 m2; Volume: 0.870878 m3
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Sofas_Vitra_Suita-Club: Suita Club Sofa; Family and Type: Furniture_Sofas_Vitra_Suita-Club: Suita Club Sofa; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Sofas_Vitra_Suita-Club: Suita Club Sofa; Type Id: Furniture_Sofas_Vitra_Suita-Club: Suita Club Sofa; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
